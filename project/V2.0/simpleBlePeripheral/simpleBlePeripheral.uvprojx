# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  AfterMake: .\bin\material\mk_hexf_bin.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_SRAM_RETENTION_LOW_CURRENT_LDO_ENABLE CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<custom_tuya_ble_config.h>  CFG_CP DEBUG_INFO=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: --diag_suppress=177,550,186,545,188,68,940 -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\PHY62XX_SDK_3.1.1\components\inc;..\..\..\PHY62XX_SDK_3.1.1\components\ble\controller;..\..\..\PHY62XX_SDK_3.1.1\components\osal\include;..\..\..\PHY62XX_SDK_3.1.1\components\common;..\..\..\PHY62XX_SDK_3.1.1\components\ble\include;..\..\..\PHY62XX_SDK_3.1.1\components\ble\hci;..\..\..\PHY62XX_SDK_3.1.1\components\ble\host;..\..\..\PHY62XX_SDK_3.1.1\components\Profiles\ota_app;..\..\..\PHY62XX_SDK_3.1.1\components\Profiles\DevInfo;..\..\..\PHY62XX_SDK_3.1.1\components\Profiles\SimpleProfile;..\..\..\PHY62XX_SDK_3.1.1\components\Profiles\Roles;.\source;..\..\..\PHY62XX_SDK_3.1.1\components\libraries\crc16;..\..\..\PHY62XX_SDK_3.1.1\components\driver\clock;..\..\..\PHY62XX_SDK_3.1.1\components\arch\cm0;..\..\..\PHY62XX_SDK_3.1.1\components\driver\pwrmgr;..\..\..\PHY62XX_SDK_3.1.1\components\driver\uart;..\..\..\PHY62XX_SDK_3.1.1\components\driver\gpio;..\..\..\PHY62XX_SDK_3.1.1\components\driver\timer;..\..\..\PHY62XX_SDK_3.1.1\misc;..\..\..\PHY62XX_SDK_3.1.1\components\driver\log;..\..\..\PHY62XX_SDK_3.1.1\components\libraries\cliface;..\..\..\PHY62XX_SDK_3.1.1\components\driver\key;..\..\..\PHY62XX_SDK_3.1.1\components\driver\pwm;..\..\..\PHY62XX_SDK_3.1.1\components\driver\adc;..\..\..\PHY62XX_SDK_3.1.1\components\driver\spi;..\..\..\PHY62XX_SDK_3.1.1\components\driver\i2c;..\..\..\PHY62XX_SDK_3.1.1\components\driver\flash;..\tuya_ble_sdk_demo\app;..\tuya_ble_sdk_demo\board;..\tuya_ble_sdk_demo\board\include;..\tuya_ble_sdk_demo\board\phy62xx\ota;..\tuya_ble_sdk_demo\board\phy62xx\service;..\tuya_ble_sdk_demo\board\phy62xx\tuya_ble_port;..\tuya_ble_sdk_demo\components\ty_util;..\tuya_ble_sdk_demo\components\ty_oled;..\tuya_ble_sdk_demo\components\ty_key_press;..\tuya_ble_sdk_demo\components\external\easylogger\inc;..\tuya_ble_sdk_demo\tuya_ble_sdk;..\tuya_ble_sdk_demo\tuya_ble_sdk\app\product_test;..\tuya_ble_sdk_demo\tuya_ble_sdk\app\uart_common;..\tuya_ble_sdk_demo\tuya_ble_sdk\extern_components\mbedtls;..\tuya_ble_sdk_demo\tuya_ble_sdk\port;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\include;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\lib;..\..\..\PHY62XX_SDK_3.1.1\components\libraries\fs;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\src;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\lib\src;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\lib;..\app;..\..\..\project
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\PHY62XX_SDK_3.1.1\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group tuya_ble_sdk_demo
    ../tuya_ble_sdk_demo/app/: tuya_ble_sdk_demo.c tuya_ble_sdk_test.c tuya_ble_bulk_data_demo.c tuya_ble_product_test_demo.c
  group tuya_ble_sdk
    ../tuya_ble_sdk_demo/tuya_ble_sdk/sdk/src/: tuya_ble_api.c tuya_ble_utils.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_event.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event_handler.c tuya_ble_feature_weather.c tuya_ble_gatt_send_queue.c tuya_ble_mutli_tsf_protocol.c tuya_ble_event_handler_weak.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/app/product_test/: tuya_ble_app_production_test.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/app/uart_common/: tuya_ble_app_uart_common_handler.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/sdk/lib/: tuya_ble_sdk_lib_arm_m0_keil.lib
    ../tuya_ble_sdk_demo/board/phy62xx/service/: tuya_ble_service.c
  group component/ty
    ../tuya_ble_sdk_demo/components/ty_oled/: ty_oled.c
    ../tuya_ble_sdk_demo/components/ty_key_press/: ty_key_press.c
    ../tuya_ble_sdk_demo/components/ty_util/: ty_util.c
  group component/mbedtls
    ../tuya_ble_sdk_demo/tuya_ble_sdk/extern_components/mbedtls/: aes.c md5.c sha1.c sha256.c
  group component/easylogger
    ../tuya_ble_sdk_demo/components/external/easylogger/inc/: elog_cfg.h elog.h
    ../tuya_ble_sdk_demo/components/external/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../tuya_ble_sdk_demo/components/external/easylogger/port/: elog_port.c
  group board
    ../tuya_ble_sdk_demo/board/phy62xx/ty_board_phy62xx/: ty_ble_phy62xx.c ty_uart_phy62xx.c ty_i2c_phy62xx.c ty_spi_phy62xx.c ty_adc_phy62xx.c ty_pwm_phy62xx.c ty_pin_phy62xx.c ty_timer_phy62xx.c ty_rtc_phy62xx.c ty_flash_phy62xx.c ty_system_phy62xx.c
    ../tuya_ble_sdk_demo/board/phy62xx/ota/: tuya_ble_ota.c
    ../tuya_ble_sdk_demo/board/phy62xx/tuya_ble_port/: tuya_ble_port_phy62xx.c custom_tuya_ble_config.h
  group Application
    ./: main.c
    ../app/: app.c app_timer.c timestamp.c app_flash.c main_logic.c app_btn.c app_bell.c app_adc_btn.c app_soc.c app_seg_lcd.c app_hall.c app_ble.c
  group driver
    ../../../PHY62XX_SDK_3.1.1/components/driver/adc/: adc.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/clock/: clock.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/flash/: flash.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/gpio/: gpio.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/key/: key.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/log/: my_printf.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/pwm/: pwm.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/pwrmgr/: pwrmgr.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/spi/: spi.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/i2c/: i2c.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/timer/: timer.c
    ../../../PHY62XX_SDK_3.1.1/components/osal/snv/: osal_snv.c
    ../../../PHY62XX_SDK_3.1.1/components/driver/uart/: uart.c
  group profile
    ../../../PHY62XX_SDK_3.1.1/components/profiles/GATT/: gattservapp.c
    ../../../PHY62XX_SDK_3.1.1/components/profiles/Roles/: central.c gapbondmgr.c gapgattserver.c peripheral.c gap.c
  group jump
    ../../../PHY62XX_SDK_3.1.1/misc/: jump_table.c
  group lib
    ../../../PHY62XX_SDK_3.1.1/lib/: ble_host.lib rf.lib
  group simpleBlePeripheral
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c
  group config
    ../../: project_config.h BT612_4_config.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
