# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  AfterMake: fromelf -c -a -d -e -v -o simpleBlePeripheral.asm ./Objects/simpleBlePeripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\PHY62XX_SDK_3.1.1\components\inc;..\..\PHY62XX_SDK_3.1.1\components\ble\controller;..\..\PHY62XX_SDK_3.1.1\components\osal\include;..\..\PHY62XX_SDK_3.1.1\components\common;..\..\PHY62XX_SDK_3.1.1\components\ble\include;..\..\PHY62XX_SDK_3.1.1\components\ble\hci;..\..\PHY62XX_SDK_3.1.1\components\ble\host;..\..\PHY62XX_SDK_3.1.1\components\Profiles\ota_app;..\..\PHY62XX_SDK_3.1.1\components\Profiles\DevInfo;..\..\PHY62XX_SDK_3.1.1\components\Profiles\SimpleProfile;..\..\PHY62XX_SDK_3.1.1\components\Profiles\Roles;..\..\PHY62XX_SDK_3.1.1\source;..\..\PHY62XX_SDK_3.1.1\components\libraries\crc16;..\..\PHY62XX_SDK_3.1.1\components\driver\watchdog;..\..\PHY62XX_SDK_3.1.1\components\driver\clock;..\..\PHY62XX_SDK_3.1.1\components\arch\cm0;..\..\PHY62XX_SDK_3.1.1\components\driver\pwrmgr;..\..\PHY62XX_SDK_3.1.1\components\driver\uart;..\..\PHY62XX_SDK_3.1.1\components\driver\gpio;..\..\PHY62XX_SDK_3.1.1\components\driver\timer;..\..\PHY62XX_SDK_3.1.1\misc;..\..\PHY62XX_SDK_3.1.1\components\driver\log;..\..\PHY62XX_SDK_3.1.1\components\libraries\cliface;..\..\PHY62XX_SDK_3.1.1\components\driver\key;..\..\PHY62XX_SDK_3.1.1\components\driver\pwm;..\..\PHY62XX_SDK_3.1.1\components\driver\flash;..\..\PHY62XX_SDK_3.1.1\components\libraries\fs;..\..\PHY62XX_SDK_3.1.1\components\driver\led_light;..\..\PHY62XX_SDK_3.1.1\components\driver\gpio;..\..\PHY62XX_SDK_3.1.1\components\inc;..\..\PHY62XX_SDK_3.1.1\components\profiles\SimpleProfile
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\PHY62XX_SDK_3.1.1\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../../PHY62XX_SDK_3.1.1/components/driver/adc/: adc.c
    ../../PHY62XX_SDK_3.1.1/components/driver/flash/: flash.c
    ../../PHY62XX_SDK_3.1.1/components/driver/gpio/: gpio.c
    ../../PHY62XX_SDK_3.1.1/components/driver/key/: key.c
    ../../PHY62XX_SDK_3.1.1/components/driver/led_light/: led_light.c
    ../../PHY62XX_SDK_3.1.1/components/driver/watchdog/: watchdog.c
    ../../PHY62XX_SDK_3.1.1/components/driver/uart/: uart.c
    ../../PHY62XX_SDK_3.1.1/components/driver/timer/: timer.c
    ../../PHY62XX_SDK_3.1.1/components/driver/pwrmgr/: pwrmgr.c
    ../../PHY62XX_SDK_3.1.1/components/driver/log/: my_printf.c
    ../../PHY62XX_SDK_3.1.1/components/osal/snv/: osal_snv.c
    ../../PHY62XX_SDK_3.1.1/components/driver/clock/: clock.c
    ../../PHY62XX_SDK_3.1.1/components/driver/pwm/: pwm.c
  group profile
    ../../PHY62XX_SDK_3.1.1/components/profiles/GATT/: gattservapp.c
    ../../PHY62XX_SDK_3.1.1/components/profiles/ota_app/: ota_app_service.c
    ../../PHY62XX_SDK_3.1.1/components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
  group jump
    ../../PHY62XX_SDK_3.1.1/misc/: jump_table.c
  group lib
    ../../PHY62XX_SDK_3.1.1/lib/: rf.lib ble_host.lib
  group simpleBlePeripheral
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c sbpProfile_ota.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
